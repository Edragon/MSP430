<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP430F5438A-TFT2.8.ewp</path>
  </project>
  <batchBuild/>
</workspace>


