<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MSP430F5438A-CLOCK.ewp</path>
    </project>
    <batchBuild />
</workspace>
