# IAR project Backup of E1.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F1481 MSP430F1481
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  group (top)
    ./: EEPROM.c IIC.c main.c
